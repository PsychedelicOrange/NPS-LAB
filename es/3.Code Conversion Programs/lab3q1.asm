	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R1,N
	LDR R5,=RES
	AND R2,R1,#0X0F
	CMP R2,#9
	BLO DIGIT
	ADD R2,#7
DIGIT 
	ADD R2,#0X30
	AND R3,R1,#0XF0
	LSR R3,#4
	CMP R3,#9
	BLO DIGIT1
	ADD R3,#7
DIGIT1
	ADD R3,#0X30
	STM R5,{R2,R3}
	
STOP B STOP
N DCD 0Xa7
	AREA MYDATA,DATA, READWRITE
RES DCD 0,0
	END