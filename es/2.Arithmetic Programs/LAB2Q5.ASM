	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,A
	LDR R1,B
LOOP
	CMP R0,R1
	BEQ DONE
	BGE GREATER
	SUB R1,R0;LESSER
	B LOOP
GREATER 
	SUB R0,R1;GREATER
	B LOOP
DONE 
	LDR R3,=RES
	STR R0,[R3]
STOP B STOP
A DCD 0X9
B DCD 0x6
	AREA MYDATA,DATA, READWRITE
RES DCD 0
	END