	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1 + 4*(N-1)
	LDR R1,=NUM2 + 4*(N-1)
	LDR R2,=RES +  4*N
	LDR R3,=0X4
	LDR R4,=0X20000000
	MSR XPSR,R4
BACK
	LDR R4,[R0],#-4
	LDR R5,[R1],#-4
	SBCS R6,R4,R5
	STR R6,[R2],#-4
	SUB R3,#1
	TEQ R3,#0
	BNE BACK
	SBC R7,#0
	STR R7,[R2]
STOP B STOP
N EQU 4
NUM1 DCD 0XF23123,0X123210,0X23134,0X43545
NUM2 DCD 0X123123,0X123210,0X23134,0XFFFFE
	AREA MYDATA,DATA, READWRITE
RES DCD 0,0,0,0,0
	END