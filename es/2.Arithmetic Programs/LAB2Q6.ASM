	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R3,=0X1 ; I
	LDR R1,=B
	LDR R1,[R1]
	LDR R0,=A
	LDR R0,[R0]
	CMP R0,R1
	BGE LOOP
	MOV R7,R0
	MOV R0,R1
	MOV R1,R7
LOOP
	MUL R5,R0,R3
UP
	SUB R5,R1
	CMP R5,R1
	BPL UP
	;R5 IS THE REMAINDER
	TEQ R5,#0
	BNE COUNTINUE
	MUL R3,R0
	LDR R4,=RES
	STR R3,[R4] 
	B STOP
COUNTINUE
	ADD R3,#1
	B LOOP
STOP B STOP
A DCD 0X3
B DCD 0x7
	AREA MYDATA,DATA, READWRITE
RES DCD 0
	END